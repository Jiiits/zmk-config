## config/boards/shields/yalice/Kconfig.defconfig
```kconfig
if SHIELD_YALICE

config ZMK_KEYBOARD_NAME
    default "Y'alice"

CONFIG_ZMK_MOUSE=y

endif
```
